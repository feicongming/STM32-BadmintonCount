# Keil uVision project badminton.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: badminton +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --locale=english
  c include: .\Hardware\BATTERY;.\Hardware\BUTTON;.\Hardware\DMA;.\Hardware\LCD;.\Hardware\LED;.\Hardware\SPI;.\Start;.\System\delay;.\System\sys;.\User;.\Library;.\Hardware\FLASH;.\System\usart;.\Hardware\BEEP;.\Hardware\TIM;.\Hardware\LM75BD;.\Hardware\BATTERY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Library
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group Hardware
    ./Hardware/BUTTON/: button.c
    ./Hardware/DMA/: dma.c
    ./Hardware/LCD/: lcd.c lcd_init.c
    ./Hardware/SPI/: spi.c
    ./Hardware/FLASH/: flash.c
    ./Hardware/BEEP/: beep.c
    ./Hardware/LED/: led.c
    ./Hardware/TIM/: tim.c
    ./Hardware/LM75BD/: lm75bd.c
    ./Hardware/BATTERY/: battery.c
  group User
    ./User/: main.c stm32f10x_it.c
